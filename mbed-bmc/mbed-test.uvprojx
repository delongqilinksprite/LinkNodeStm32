# Keil uVision project mbed-test.uvprojx, settings and files
target mbed-test (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: mbed-test
  c flags: Optim=2 uC99=1
  c misc: -DDEVICE_RTC=1 -O0 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h --restrict -DTARGET_STM32F4 -D__ASSERT_MSG --no_rtti -DDEVICE_SLEEP=1 -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -g -DTARGET_STM32F411RE -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_SERIAL_ASYNCH=1 --split_sections --multibyte_chars --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DDEVICE_I2C=1 -DTARGET_NUCLEO_F411RE -DDEVICE_PORTIN=1 -DTARGET_STM --brief_diagnostics -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DMBED_BUILD_TIMESTAMP=1476432536.45 -DTOOLCHAIN_ARM -DTARGET_DEBUG --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SERIAL_FC=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .; ./mbed-os; ./mbed-os/hal; ./mbed-os/hal/hal; ./mbed-os/hal/hal/storage_abstraction; ./mbed-os/hal/api; ./mbed-os/hal/targets; ./mbed-os/hal/targets/hal; ./mbed-os/hal/targets/hal/TARGET_STM; ./mbed-os/hal/targets/hal/TARGET_STM/TARGET_STM32F4; ./mbed-os/hal/targets/hal/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE; ./mbed-os/hal/targets/cmsis; ./mbed-os/hal/targets/cmsis/TARGET_STM; ./mbed-os/hal/targets/cmsis/TARGET_STM/TARGET_STM32F4; ./mbed-os/hal/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE; ./mbed-os/hal/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE/TOOLCHAIN_ARM_STD; ./mbed-os/hal/common; ./mbed-os/rtos; ./mbed-os/rtos/rtx; ./mbed-os/rtos/rtx/TARGET_CORTEX_M; ./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; ./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM; ./mbed-os/rtos/rtos; ./mbed-os/features; ./mbed-os/features/net; ./mbed-os/features/net/network-socket; ./mbed-os/features/mbedtls; ./mbed-os/features/mbedtls/importer; ./mbed-os/features/mbedtls/inc; ./mbed-os/features/mbedtls/inc/mbedtls; ./mbed-os/features/mbedtls/src; ./mbed-os/features/frameworks; ./mbed-os/features/frameworks/unity; ./mbed-os/features/frameworks/unity/unity; ./mbed-os/features/frameworks/unity/source; ./mbed-os/features/frameworks/greentea-client; ./mbed-os/features/frameworks/greentea-client/source; ./mbed-os/features/frameworks/greentea-client/greentea-client; ./mbed-os/features/frameworks/utest; ./mbed-os/features/frameworks/utest/source; ./mbed-os/features/frameworks/utest/utest; ./mbed-os/features/storage; ./mbed-os/docs
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__CMSIS_RTOS,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ./mbed-os/hal/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE/TOOLCHAIN_ARM_STD/stm32f411re.sct
  group TARGET_CORTEX_M
    mbed-os/rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
  group TARGET_NUCLEO_F411RE
    mbed-os/hal/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE/: cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.c hal_tick.h stm32f411xe.h stm32f4xx.h stm32f4xx_hal_conf.h system_stm32f4xx.c system_stm32f4xx.h
    mbed-os/hal/targets/hal/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE/: objects.h PeripheralNames.h PeripheralPins.c PinNames.h PortNames.h
  group TARGET_STM32F4
    mbed-os/hal/targets/hal/TARGET_STM/TARGET_STM32F4/: analogin_api.c analogout_api.c can_api.c common_objects.h device.h entropy_hardware_poll.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c mbed_overrides.c PeripheralPins.h pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    mbed-os/hal/targets/cmsis/TARGET_STM/TARGET_STM32F4/: stm32_hal_legacy.h stm32f4xx_hal.c stm32f4xx_hal.h stm32f4xx_hal_adc.c stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.c stm32f4xx_hal_can.h stm32f4xx_hal_cec.c stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.c stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.c stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.c stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.c stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.c stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.c stm32f4xx_hal_eth.h stm32f4xx_hal_flash.c stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.c stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.c stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.c stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.c stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.c stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.c stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nand.h stm32f4xx_hal_nor.c stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.c stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.c stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.c stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.c stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.c stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.c stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.c stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.c stm32f4xx_hal_spi.h stm32f4xx_hal_sram.c stm32f4xx_hal_sram.h stm32f4xx_hal_tim.c stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.c stm32f4xx_hal_uart.h stm32f4xx_hal_usart.c stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.c stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.c stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.c stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.c stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.c stm32f4xx_ll_usb.h
  group TOOLCHAIN_ARM
    mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.S
  group TOOLCHAIN_ARM_STD
    mbed-os/hal/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE/TOOLCHAIN_ARM_STD/: startup_stm32f411xe.S sys.cpp
  group api
    mbed-os/hal/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h PlatformMutex.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SingletonPtr.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
  group cmsis
    mbed-os/hal/targets/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group common
    mbed-os/hal/common/: AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_gpio.c mbed_interface.c mbed_lp_ticker_api.c mbed_mem_trace.c mbed_pinmap_common.c mbed_rtc_time.cpp mbed_semihost_api.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_wait_api.c RawSerial.cpp retarget.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group greentea-client
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_serial.h test_env.h
  group hal
    mbed-os/hal/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
  group mbed-test
    ./: main.cpp mbed_config.h
  group mbedtls
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group network-socket
    mbed-os/features/net/network-socket/: CellularInterface.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiInterface.h
  group rtos
    mbed-os/rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group source
    mbed-os/features/frameworks/greentea-client/source/: greentea_serial.cpp test_env.cpp
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
  group src
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group storage_abstraction
    mbed-os/hal/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group unity
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
  group utest
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group LinkNode
    ./LinkNode/: Beep.cpp Beep.h BME280.cpp BME280.h DHT22.cpp DHT22.h IRSender.cpp IRSender.h Relay.cpp Relay.h Temp6000.cpp Temt6000.h Thumb.cpp Thumb.h TM1637.cpp TM1637.h
